# Autodesk Inventor assembly: 21.0978 ANGLE 90
## iProperties
Created: 2012-01
Part Number: 21.0978 ANGLE 90
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
